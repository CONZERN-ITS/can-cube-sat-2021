File: schematics/board/SPIDERnew.sch (EAGLE design)
At the start: 9 parts

Commit message: плата БСК5
Other:
- moved on the sheet: U$5
