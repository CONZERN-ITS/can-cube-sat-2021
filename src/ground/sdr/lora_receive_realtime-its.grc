options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: lora_receive_realtime
    output_language: python
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: sf * (1 / (2**sf / float(bw)))
  states: {}
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: capture_freq
  id: variable
  parameters:
    value: 438125e3
  states: {}
- name: decimation
  id: variable
  parameters:
    comment: |-
      The decimation determines the oversampling rate.
      A sample rate of 1e6 and decimation of 1 equals
      8 times oversampling, a decimation of 2 is 4 times
      oversampling, and so on. Set higher decimation
      for better performance, but worse accuracy.
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: float(bw) / (2**sf)
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 438125e3
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: 1e6
    sf: sf
  states: {}
- name: lora_message_socket_sink_0
  id: lora_message_socket_sink
  parameters:
    ip: 192.168.1.224
    layer: '0'
    port: '40868'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: capture_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [lora_lora_receiver_0, frames, lora_message_socket_sink_0, in]
- [osmosdr_source_0, '0', lora_lora_receiver_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
